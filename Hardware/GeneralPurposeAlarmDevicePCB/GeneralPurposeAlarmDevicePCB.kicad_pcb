# Repository PubInv/general-purpose-alarm-device

File README.md (part):

# General Purpose Alarm Device v2.0
We often acronymize this as  "GPAD" (pronounced gee-pad).

DOI: [https://zenodo.org/records/10065096](https://zenodo.org/records/10065096)

## Abstract 
The General Purpose Alarm Device (GPAD) shines lights and makes loud noises to draw attention to a problem. It has a programmable 80 character display to provide textual info. A mute button toggles the sound on and off. Fundamentally, it is designed to act as a peripheral to a controlling computer or microcontroller. The controller may communicate over a USB (COM) connection or through a 5V SPI connection via an RJ12 cable. The GPAD is intended to be as general as possible, so that it can be used as an alarm for many engineering, scientific, and hobby machines or instruments. The device's original goal was to provide medical alarm capability to the PolyVent [5]open-source mechanical medical ventilator. The GPAD supports 5 alarm levels above “silent” of increasing urgency in terms of light, rhythm, and frequency. It is based on the Arduino Uno Atmega328 design and may similarly become extensible through headers and shields. It includes a printed wiring assembly, firmware for the GPAD peripheral, a simple documented API, and a 3D printable enclosure. The repo includes instructions for using a second GPAD as a controller.

The GPAD does not detect the conditions that need to be alarmed. It is a peripheral to a controlling host device, probably another microcontroller.
The controlling host will assert status through the GPAD to an end user.

## Demonstration Video
A demonstration of one use of the GPAD can be [seen here](https://youtu.be/F5cf5-Cmwu0).

# Collaborative Open Development

Development of the GPAD is in collaboration with the [Sustainable Progress and Equality Collective
(SPEC)](https://www.specollective.org/#:~:text=The%20Sustainable%20Progress%20and%20Equality,be%20catalysts%20for%20positive%20change.) and other individual volunteers.

The GPAD is Certified Open Source Hardware by OSHWA. Our OSHWA UID is [US002352](https://certification.oshwa.org/us002352.html).

GPAD in an Enclosure of Summer 2022

KiCad Simulated GPAD Printed Circuit Assembly (Version 2)

**Top View**

**Bottom View.** 

The top view image shows some Artuino UNO connectors peeking out, but on the bottom view the connectors are not actually used.  The GPAD was designed so that it MIGHT become a shield to an UNO, but it can stand alone.

# Versions History
During the summer of 2022, Version 1 of the GPAD PCB was designed and several units were fabricated.
Some of these units were used as electrical engineering senior capstone projects of students at the
University of Oklahoma, located in Nornam Oklahoma, during the spring semester.
Two groups participated: one group developed a wireless interface and battery features, and
the other groups developed a voice playback feature.
These features are on the ESP32 branch, some of which appear in the [Krake](https://github.com/PubInv/krake) project.

## GPAD V1 Repository Tag
Tag to last commit before removing information of Version 1 PCB and PCBA
https://github.com/PubInv/general-purpose-alarm-device/releases/tag/BeforeRemovingV1Files.

## Version 2 PCB Features
As of March 2023, we developed and built a version 2 PCB.  Fifteen printed wiring assemblies and five enclosures were fabricated largely by JLCPCB.
Some PCB components not available through JLCPCB were assembled by hand in Maryville, TN.
Details of the assembly and test procedure can be found through links in the README.md at:  [https://github.com/PubInv/general-purpose-alarm-device/tree/main/Hardware](https://github.com/PubInv/general-purpose-alarm-device/tree/main/Hardware).

**FIXES in Version 2**
Changes were made in version 2 to fix a few reworks to version 1 PCBs, which involved cutting traces and soldering wires.
The most noticable change was properly connecting the USB-UART chip to the micocontroller nRESET line
so that the devices can program themselves without the user having to press the reset button.
Another change was making the audio output a switch rather than a push-pull, which allows for an internally driven buzzer and greater volume.
We built buzzers with Digi-key part numbers 433-WST-1210T-ND and 102-CMI-1295-0585T-ND. Both are rated at 85 dB and 10cm.
The Rev2 can also drive the **VERY **loud Floyd Bell Inc buzzer 2339-TXC-86-515-Q-ND, rated at 103dB. However, we have not designed an enclosure for the "off board" mounting requirements of this device.
An additional Rev 2 feature is a silk screen on all of the "Arduino UNO" connectors, which look like pins for easy signal indentification.

## GPAD V2 Build Information
Below are files we used to build the V2 assemblies. The PCB with some SMT Assembly was from JCLPCB in China. Additional parts were ordered and hand soldered in the USA.

[Linkes to the schematic and PCB design found here](./Hardware/GeneralPurposeAlarmDevicePCB)
[Links to the exact Gerber files GerbersV120220804.zip](./Hardware/Manufacturing/GerbersV120220804.zip)
[Information on the V2 build of April 2023](/Hardware/Manufacturing)
[Manufacturing and Unit Test Documentation, PCB Version 2.0, 20230228](./Hardware/Documentation/ManufacturingUnitTestTroubleshootingRev2.md)
Details on how to assemble the Printed Wiring Assemblies as received from the JLCPCB version 2 PCBs of March 2023. Includes testing and troubleshooting notes.

# Example Use Case, The Ventilator

The [Freespireco Project](https://github.com/PubInv/freespireco) is an attempt to build a
modular ecosystem of cooperating respiration devices.
Devices such as ventilators and oxygen concentrators need to have the ability to alert someone to dangerous conditions.
These alerts can be as simple and gentle as, "It is time for scheduled maintenance,"
to the far more agressive, "The hose connected to the patient is disconnected!"
The purpose of the alarm is to get the attention of nurses or doctors who can fix the problem.

See the PolyVent project on Gitlabs at: [https://gitlab.com/polyvent](https://gitlab.com/polyvent)
See the PolyVent controller at: [https://gitlab.com/polyvent/polyvent_control_module](https://gitlab.com/polyvent/polyvent_control_module)

# The Abstract Application Programmers Interface

GPAD offers a simple API for commanding the device to alarm.
We can imagine a system that supports five levels of alarm severity.
Additionally, an alarm condition normally has a short
message associated with it, such as "Hose disconnect", which
might be displayed on a small screen.

The initial version of this API is extraordinarily simple:
alarm at a level between zero and five, where zero means no alarm.
However, it is clear this API will have to evolve over time.
Issues such as when one alarm level supersedes another, when it is
acceptable to silence an alarm and for how long, etc., quickly complicate this function.

We hope that by clearly defining this version of API, we can make an evolving device of great
utility for a wide variety of purposes.

# Stand-alone or Sub-assembly

Our fully finished design includes a printed wiring assembly and an enclosure.
We freely provide all open source KiCad schematic printed circuit assembly files, so
that users can fabricate just the PCB while using an enclosure of their own design.
The enclosure is designed in the free open source program SCAD,
and we provide these files as well.
Users could fabricate this enclosure as is, or
develop a modified enclosure with their own features from the files provided.

# The Arduino UNO-Like Platform

The implementation is Arduino UNO-like.
We provide a USB interface to an ATmega328 controller for Arduino IDE compatibility, which supports a typical Arduino serial port interface for development and debugging.
Additionally, although the enclosure is not designed for them, we also provide an UNO footprint for shields. There are holes on the PCB where users can solder female Dupont headers and add UNO shields for feature enhancement and evaluation.
The enclosure design is open source so that interested persons
can add these applications according to their requirements.

# How is the alarm signal received?

The SPI Peripherial is a wired RJ12(6P6C) data connection from a host in an SPI controller, and the GPAD is an SPI Peripheral.  A data cable is wired pin 1 to pin 1 on the RJ12(6P6C) connectors. CAUTION: Telephone cables wire pin 1 to pin 6 and are not compatible.

# Summer 2023 Project Status

### Firmware
Demonstration of SPI controller and Peripheral for single byte transmission.

### Hardware
* PCB designed for a predominantly surface mount production. We used JLCPCB. Some had assembly parts not available through JLCPCB.
* An enclosure for the electronics which is designed for easy mounting (for example, with flanges for zip ties.)
* RJ12 Data Cable connection for signal (and optional power) between host and GPAD.
* Light alert by five, 5 mm white LEDs driven at about 20 mA.
* Acoustic alert by 5V buzzer, 85 dB at 10 cm. On board Piezo self-excited buzzer, or through a 0.1" two pin header for off board buzzer (103 dB).
* Text display with back lit, 20x4 character LCD.
* Single User Button labeled "MUTE" on enclosure.
* Recessed reset button.
* Power on status LED.
* USB port for Firmware development and low power operation.
* An I2C output for controller of devices TBD. Connection by locking JST connector: S04B-XASK-1(LF)(SN).
* Power from wall supply on barrel jack 2. 1mm at 9-12V <= 1000mA (or from host controlling device at 5V or 12V on the SPI interface).

### A Simulation with WokWi
Our project development benefited greatly from Wokwi.  Visit: [https://wokwi.com/](https://wokwi.com/)
In parallel with schematic capture, PCB design, and fabrication,
we have written both the diagram and two sketches that simulate our hardware in the "simulation" directory.
One of them,
which Rob wrote on Saturday, August 13th, implements [this rudimentary api](https://github.com/PubInv/general-alarm-device/tree/main/simulation/robSimulatinSat13), without supporting messages.
The other shows the use of the LCD.
These should be integrated together to create the initial firmware for the project.
Meanwhile, we can simulate the device successfully in WokWi.
While the Version 1 PCBs and PCAs were on order, Lee wrote and simulated factory test software on WokWi.
See project at: https://wokwi.com/projects/345960281987351124

Factory Test Simulation files can be found at: [./simulation/FactoryTest](./simulation/FactoryTest)
Although we eventually sent a Rev 1 GPAD to Oluseyi 'Seyi' Adeniyi (@NULLbodyHERE) made enhancements
to our factory test without even having hardware (we later sent him one), which he used to enhance
the sonic and light signalling.

# Modular Software Architecture

This is intended to be a long-term project that will evolve and potentially have many volunteers.
The basic software architecture is captured in this diagram:

# Our Simple API (Implemented!)

The simplest API is:
```
enum AlarmLevel { silent, informational, problem, warning, critical, panic };
int Alarm(AlarmLevel al);
```

The simplest binding for this, which could be used with SPI or a serial port, would simply be the character A followed by the character 0, 1, 2, 3, 4, or 5.
To test the alarm system of the serial port, you could simply type "A3" into the Arduino IDE serial monitor and send this to the GPAD, which you would expect to set off a moderate noise and flashing light.

A slight improvement on this is to specify a message. We have decided that messages should have 80 character, 32 character, and 16 character
versions, and the hardware device will do its best job rendering them in with available hardware:
```
enum AlarmLevel { silent, informational, problem, warning, critical, panic };
int Alarm(AlarmLevel al);
int Alarm80(AlarmLevel al,char* msg);
int Alarm32(AlarmLevel al,char* msg);
int Alarm16(AlarmLevel al,char* msg);
```
Additionally, it would be nice to have a way to interrogate the current alarm level:
```
AlarmLevel getAlarm(AlarmLevel al);
boolean isMuted();
```

## The Abstract API
The Abstract API is meant to work independent of specific hardware on
the GPAD. That is, it should be useful for hardware built by other teams
with significantly different decisions.

In this API, the message strings support only the most limited
sort of formatting: a linefeed character represents a line break.
Nonetheless, if linefeed characters are used, this will break lines
and of course limit the number of ACTUAL characters
that can be rendered, rather than the 60 that we can render if no
line breaks are used.

## The Hardware API

The Hardware API gives a caller complete access to all of the GPAD
hardware. For example, they could address each LED separately.
This is a lower priority. This API is not intended to be used by
medical devices because it is fragile with respect to improvements in
the hardware. Nonetheless, its availability makes the GPAD more useful
for a wider variety of purposes. For example, someone could program a
simple game with the GPAD.

## Separate transport protocols

In practice, the device needs three ways of invoking the API:
1. Through a human-typable string at the serial port,
1. Through a remote procedure call via the serial port, and
1. Through the SPI interface.

It is our intention to keep all of these mechanisms distinct from the
two APIs. There might even be additional transport protocols in the future,
such as a library that uses I2C ("I-squared C").

# Building the Firmware

The firmware can be built with the standard Arduino IDE.  (Using 1.8.19 as of 20221208)
It requires libraries:
1. Wire.h
1. LiquidCrystal_I2C.h
1. DailyStruggleButton.h  (Installed with library manager and found at: https://github.com/cygig/DailyStruggleButton)

# Evolution Stages of the Project
Ideas from the capstone projects:
1. Wifi interface and battery power.
2. Audio voice playback for messages.

Some of these capabilities, such as Wifi enablement, have been seen to fruition in the Krake project: [https://github.com/PubInv/krake](https://github.com/PubInv/krake).

In each of these phases, we imagine further extensions of the API.

# Recent News and Publications
An article about the GPAD was published in the HardwareX journal in December 2024 [https://www.hardware-x.com/article/S2468-0672(24)00084-1/fulltext](https://www.hardware-x.com/article/S2468-0672(24)00084-1/fulltext).

# Volunteer Skills (and Skills Needed)

## Current Volunteers:

Project Lead, Product Definition:  Robert L. Read (@RobertLRead), founder of Public Invention.

Enclosure design, component procurement for rev1, project facilitator, initial board bring-up, board layout design contributor: Lawrence Kincheloe (@LokeMetaSmith) of Speccollective who is a computer scientist by training, and an electrical engineer as well as a hobby inventor by vocation.

Mentor and coach hardware, firmware: (Forrest) Lee Erickson @ForrestErickson, Physicist who pretends to be an electrical engineer, with experience in firmware development, Design for Manufacture, Design for Test and developer of Novel and Diverse Spelling.

Factory Test and API Firmware Contributor: Oluseyi 'Seyi' Adeniyi @NULLbodyHERE, Software Engineer, committed to pursuing diverse creative endeavors.

## Needed Volunteers

We need volunteer:
1. Arduino engineers who can both code and make very simple circuits.
2. Schematic capture and PCB layout designers.  We are using KICAD.
3. Mechanical engineers who can design sturdy enclosures that keep the system bright and loud.
4. Embedded firmware engineers who can design an effective, evolving API and the transport bindings that they require.
5. GUI experts who can address issues such as how to effectively alarm and silence device.
6. Marketers who can promote and evangelize the project.
7. A possible project manager who can organize volunteers and keep them enthused and motivated to move forward.
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
## KiCad design Hardware/GeneralPurposeAlarmDevicePCB/GeneralPurposeAlarmDevicePCB.kicad_pcb

File Hardware/GeneralPurposeAlarmDevicePCB/README.md:

#  View KiCad files with on line viewer 
View both cchematic and PCB files with Kicanvas
These are Rev 2 files.

##  View Schematics on Line

[Main Page GPAD Rev2](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FGeneralPurposeAlarmDevicePCB.kicad_sch)

[AlarmAudio.kicad_sch](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FAlarmAudio.kicad_sch)  

[AlarmLights5.kicad_sch](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FAlarmLights5.kicad_sch)  

[LCD And I2C Interface.kicad_sch](https://kicanvas.org/?https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FLCD+And+I2C+Interface.kicad_sch=&github=https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FLCD%2520And%2520I2C%2520Interface.kicad_sch)  

[SPI Peripherial.kicad_sch](https://kicanvas.org/?https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FSPI+Peripherial.kicad_sch=&github=https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FSPI%2520Peripherial.kicad_sch)  

[USB_UART.kicad_sch](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FUSB_UART.kicad_sch)  

##  View PCB on Line
[GPAD Rev 2 PCB](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2FPubInv%2Fgeneral-alarm-device%2Fblob%2Fmain%2FHardware%2FGeneralPurposeAlarmDevicePCB%2FGeneralPurposeAlarmDevicePCB.kicad_pcb)

##  SPI Peripherial Pins  
The connector is JR12 6P6C and pin 1 is on the left when the connector is held with the contact pins up and facing the observer.  
Note the GPAD is a 5V logic level periphieral device. Level shifters must be used when controlled by a 3.3V device.  
| **Pin#** 	| **Signal Name** 	| **Note**                                            	|
|----------	|-----------------	|-----------------------------------------------------	|
| 1        	| nCS             	| Active low                                          	|
| 2        	| COPI            	| Input to GPAD                                       	|
| 3        	| GND             	|                                                     	|
| 4        	| SCK             	| Input to GPAD                                       	|
| 5        	| ControllerVcc   	| 5 Volts, an optional way to put power into the GPAD 	|
| 6        	| CIPO            	| Output from GPAD, 5V.                               	|

Board: 2 copper layers, 137.1 x 83.8 mm, 166 parts (18 on the bottom side), 104 nets.

Parts:
A101: Arduino_UNO_R3_Shield; Arduino_UNO_R3_NoMountingHoles3D
BZ601: Buzzer_Adafruit_P1536A; Buzzer_12.2mm_9.7mm_7.62mm
C1, C2, C103, C105, C108, C110, C111, C301, C501, C503, C602: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C102, C106, C109, C112, C302, C502, C601: 47uF 16V; CP_Elec_5x5.4
C101, C104, C107, C113, C114: 39pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C702: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D101, D103, D104: Schottky 2A; D_SMB
D2, D102, D106, D703: RED 0603; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D105: LED_T1.75_CLEAR_RED; LED_5mm_Radial
D201, D202, D203, D204, D205: LED_T1.75_CLEAR_WHITE; LED_5mm_Radial
D501: RED 0603; LED_0603_1608Metric
D701: ORANGE 0603; LED_0603_1608Metric
D702: GREEN 0603; LED_0603_1608Metric
D704: PMEG3020EP; D_SOD-128
F101, F401: Polyfuse_Small; Fuse_0603_1608Metric
H101, H102, H103, H104, H105: MountingHole_Pad_3.5mm; MountingHole_3.5mm_Pad_Via
J101: Barrel_Jack_Switch_SMT; BarrelJack_CLIFF_FC681465S_SMT_Horizontal
J102, J103: 0.100_2Pin; PinHeader_1x02_P2.54mm_Vertical
J105: S04B-XASK-1(LF)(SN)Rev2
J401: RJ12_6P6C_HORZ; RJ12_Amphenol_54601
J501: USB_B_Micro_Local; USB_Micro-B_Amphenol_10118194_Horizontal
J601, J602: 22-23-2021; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J701: BATT_JST; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
MF103, MF601, MF602, MF603, MF604, MF605: U_Box_V104_General_Alarm_Device_LED_Standoff
Q201, Q202, Q203, Q204, Q205: MMBT2222A-7-F; SOT-23
Q301, Q601: BSS138; SOT-23
Q302: AOSS21311C; SOT-23-3
Q302#2: AOSS21311C; SOT-23
Q602: DNI; SOT-23-3
R2, R102, R505, R603: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R103, R108, R109, R304, R602, R705: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R110, R111, R112, R202, R204, R206, R208, R210, R401, R402, R403, R404, R501, R502, R503, R605, R701, R702, R703: 330R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R101, R305, R307, R309, R310: 1R0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R104, R105: 39R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R106, R107, R306, R308, R506, R604: DNI; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R201, R203, R205, R207, R209, R301, R302, R303, R311, R312, R504: 4K7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R507, R508, R601: 1R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R704: 2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R706: 150K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV301: POT 0.375 10K; Potentiometer_Bourns_3386P_Vertical
S1, S101: SWITCH_TACTILE_SPST-NO_0.05A_24V; Switch_Tactile_THT_6x6mm
S601: SWITCH_TACTILE_12mmx12mm_SPST-NO_0.05A_24V; SW_PUSH-12mm_WithCap_Green
T1, T2, T3: JLC_ToolingHole_0576mm
TH701: 10k Therm; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP101: TP_GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP102: Vin; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP103: +5V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP104: VccController; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP105: 3.3V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP201: VBus; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP202: V3; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP203: nCTS; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP401: Vcc_LCD; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP402: nINT; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP501: VccBuzzer; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U3: ESP32-WROOM-32
U101: LM7805_TO220; TO-220-3_Horizontal_TabDown
U102: PI_ATMEGA328P-AU-InOrder; TQFP-32_7x7mm_P0.8mm
U301: PCF8574AT_3_518; SOIC-16W_7.5x10.3mm_P1.27mm
U302: LCD_20x4_Character-GPAD_SCH_LIB; LCD_2004A
U501: CH340E; MSOP-10_3x3mm_P0.5mm
U701: MCP73833; DFN-10-1EP_3x3mm_P0.5mm_EP1.7x2.5mm
XTAL101: 16MHZ 20PF HC-49S/SMD; Crystal_SMD_HC49-SD

Connections:
+5V: A101.2 (IOREF), A101.5 (+5V), C108.1, C109.1, D701.2 (A), D702.2 (A), D703.2 (A), D704.1 (K), J102.1, J105.4, Q302.3 (S), Q302#2.2 (S), R101.2, R106.2, R110.2, R202.2, R204.2, R206.2, R208.2, R210.2, R310.2, R601.2, R603.2, TP103.1, U101.3 (VO), U701.1 (VDD1), U701.2 (VDD2)
/AlarmAudio/VccBuzzer: BZ601.1 (-), C601.1, J601.1, R506.2, R601.1, TP501.1
/LCD And I2C Interface/Vcc_LCD: C301.1, C302.1, Q302.2 (D), Q302#2.3 (D), R301.2, R302.2, R303.2, R304.2, R306.2, R310.1, R311.2, RV301.3, TP401.1, U301.16 (VDD), U302.2 (VDD), U302.15 (A)
Attenuate: A101.19 (D4), R605.1, U3.16 (IO13), U102.2 (PD4)
CIPO: A101.27 (D12), R401.1, U3.31 (IO19), U102.16 (PB4)
COPI: A101.26 (D11), R403.1, U3.37 (IO23), U102.15 (PB3)
ControllerRX: A101.15 (D0/RX), R502.1, U3.35 (TXD0/IO1), U102.30 (PD0)
ControllerTX: A101.16 (D1/TX), R503.1, U3.34 (RXD0/IO3), U102.31 (PD1)
ControllerVcc: F401.1, J103.2, R107.1
GND: A101.6 (GND), A101.7 (GND), A101.29 (GND), C2.2, C3.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C111.2, C112.2, C113.2, C114.2, C301.2, C302.2, C501.2, C502.2, C503.2, C601.2, C602.2, C702.2, D2.1 (K), D102.1 (K), D105.2, D106.1 (K), D501.1 (K), H101.1, H102.1, H103.1, H104.1, H105.1, J101.2, J101.3, J105.2, J401.3, J501.5 (GND), J501.6 (Shield), J602.2, J701.2, Q201.2 (E), Q202.2 (E), Q203.2 (E), Q204.2 (E), Q205.2 (E), Q301.2 (S), Q602.3 (C), R305.2, R307.2, R308.1, R309.2, R504.1, R505.1, R508.1, R704.2, R706.2, RV301.1, S1.3, S1.4, S101.3, S101.4, S601.3, S601.4, TH701.2, TP101.1, U3.1 (GND), U3.15 (GND), U3.38 (GND), U3.39 (GND), U101.2 (GND), U102.3 (GND), U102.5 (GND), U102.21 (GND), U301.8 (VSS), U302.1 (VSS), U302.7 (DB0)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
LCD power: Q302.1 (G), Q302#2.1 (G), U102.22 (ADC7)
Light0: A101.18 (D3), R201.2, U3.10 (IO25), U102.1 (PD3)
Light1: A101.20 (D5), R203.2, U3.11 (IO26), U102.9 (PD5)
Light2: A101.21 (D6), R205.2, U3.12 (IO27), U102.10 (PD6)
Light3: A101.24 (D9), R207.2, U3.13 (IO14), U102.13 (PB1)
Light4: A101.22 (D7), R209.2, U3.23 (IO15), U102.11 (PD7)
unnamed: BZ601.2 (+), J601.2, R507.1, R604.1
unnamed: C101.1, F101.2, J101.1, J101.4
unnamed: C103.1, C106.1, R101.1, TP104.1
unnamed: C113.1, J105.3, R104.1
unnamed: C114.1, J105.1, R105.1
unnamed: D1.2 (A), R2.1
unnamed: D1.1 (K), R2.2
unnamed: D2.2 (A), R6.1
unnamed: D101.2 (A), F101.1
unnamed: D102.2 (A), R103.1
unnamed: D104.2 (A), J103.1, R107.2
unnamed: D105.1, R110.1
unnamed: D106.2 (A), R112.1
unnamed: D201.1, R202.1
unnamed: D202.1, R204.1
unnamed: D203.1, R206.1
unnamed: D204.1, R208.1
unnamed: D205.1, R210.1
unnamed: D501.2 (A), R501.2
unnamed: D701.1 (K), R701.1
unnamed: D702.1 (K), R702.1
unnamed: D703.1 (K), R703.1
unnamed: C702.1, D704.2 (A), J701.1, U701.9 (VBAT1), U701.10 (VBAT2)
unnamed: F401.2, J401.5
unnamed: J401.1, R404.2
unnamed: J401.2, R403.2
unnamed: J401.4, R402.2
unnamed: J401.6, R401.2
unnamed: J501.3 (D+), U501.1 (UD+)
unnamed: J501.2 (D-), U501.2 (UD-)
unnamed: Q201.1 (B), R201.1
unnamed: D201.2, Q201.3 (C)
unnamed: Q202.1 (B), R203.1
unnamed: D202.2, Q202.3 (C)
unnamed: Q203.1 (B), R205.1
unnamed: D203.2, Q203.3 (C)
unnamed: Q204.1 (B), R207.1
unnamed: D204.2, Q204.3 (C)
unnamed: Q205.1 (B), R209.1
unnamed: D205.2, Q205.3 (C)
unnamed: Q301.3 (D), U302.16 (K)
unnamed: Q301.1 (G), R312.1
unnamed: Q601.3 (D), R506.1, R507.2
unnamed: Q601.1 (G), Q602.1 (B), R505.2, R602.1, R605.2
unnamed: Q601.2 (S), Q602.2 (E), R508.2, R604.2
unnamed: R3.1, R4.1
unnamed: R705.2, R706.1, TH701.1
unnamed: R5.2, U3.3 (EN)
unnamed: C104.1, U102.7 (XTAL1/PB6), XTAL101.1
unnamed: C107.1, U102.8 (XTAL2/PB7), XTAL101.2
unnamed: R303.1, R309.1, U301.1 (A0)
unnamed: R302.1, R307.1, U301.2 (A1)
unnamed: R301.1, R305.1, U301.3 (A2)
unnamed: U301.4 (P0), U302.4 (RS)
unnamed: U301.5 (P1), U302.5 (R/W)
unnamed: U301.6 (P2), U302.6 (E)
unnamed: R311.1, R312.2, U301.7 (P3)
unnamed: U301.9 (P4), U302.11 (DB4)
unnamed: U301.10 (P5), U302.12 (DB5)
unnamed: U301.11 (P6), U302.13 (DB6)
unnamed: U301.12 (P7), U302.14 (DB7)
unnamed: R304.1, TP402.1, U301.13 (~INT)
unnamed: R306.1, R308.2, RV301.2, U302.3 (VO)
unnamed: R503.2, U501.9 (RXD)
unnamed: R501.1, U501.6 (TNOW)
unnamed: R502.2, U501.8 (TXD)
unnamed: C503.1, TP202.1, U501.10 (V3)
unnamed: R504.2, TP203.1, U501.5 (~CTS)
unnamed: R703.2, U701.7 (PG)
unnamed: R704.1, U701.6 (PROG)
unnamed: R701.2, U701.3 (STAT1)
unnamed: R702.2, U701.4 (STAT2)
unnamed: R705.1, U701.8 (THERM)
PC0: A101.9 (A0), U3.6 (IO34), U102.23 (PC0)
PC1: A101.10 (A1), U3.7 (IO35), U102.24 (PC1)
PC2: A101.11 (A2), U3.8 (IO32), U102.25 (PC2)
PC3: A101.12 (A3), R6.2, U3.9 (IO33), U102.26 (PC3)
SCL: A101.14 (SCL/A5), A101.32 (SCL/A5), R4.2, R104.2, R109.2, U3.36 (IO22), U102.28 (PC5), U301.14 (SCL)
SDA: A101.13 (SDA/A4), A101.31 (SDA/A4), R3.2, R105.2, R108.2, U3.33 (IO21), U102.27 (PC4), U301.15 (SDA)
SPI_SCK: A101.28 (D13), R103.2, R402.1, U3.30 (IO18), U102.17 (PB5)
Switch_Mute: A101.17 (D2), C602.1, J602.1, R603.1, S601.1, S601.2, U3.14 (IO12), U102.32 (PD2)
Tone: A101.23 (D8), R602.2, U3.26 (IO4), U102.12 (PB0)
VBus: C501.1, C502.1, J102.2, J501.1 (VBUS), R106.1, TP201.1, U501.7 (VCC)
VccController: A101.30 (AREF), C111.1, C112.1, D103.1 (K), R102.2, R108.1, R109.1, U102.4 (VCC), U102.6 (VCC), U102.18 (AVCC), U102.20 (AREF)
Vin: A101.8 (VIN), C102.1, C105.1, D101.1 (K), D104.1 (K), TP102.1, U3.2 (VDD), U101.1 (VI)
nCS: A101.25 (D10), R404.1, U3.29 (IO5), U102.14 (PB2)
nRESET: C1.1, C110.1, D103.2 (A), R5.1, R102.1, S1.1, S1.2, S101.1, S101.2, U102.29 (~RESET/PC6)
nRTS: C1.2, C110.2, U501.4 (~RTS)

File Hardware/Manufacturing/GeneralAlarmDeviceV120220810-BOM_JLCSMT.xlsx:

Comment | Designator | Footprint | JLCPCB Part #（optional）
Buzzer_12.2mm_H6.5mm | BZ601 | Buzzer_Beeper:Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm | C76871
39pF | C101, C104, C107, C113, C114 | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | C107049
47uF 16V | C102, C106, C109, C112, C302, C502, C601 | Capacitor_SMD:CP_Elec_5x5.4 | C2895272
100nF | C103, C105, C108, C110, C111, C301, C501, C503, C602 | Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder | C14663
Schottky 2A | D101, D103, D104 | Diode_SMD:D_SMB | C14996
RED 0603 | D102 | digikey-footprints:0805 | C2286
LTL2R3KEK | D105 | GeneralPurposeAlarmDevicePCB:LED_5mm_Radial | 160-1682-ND
LED_T1.75_CLEAR_WHITE | D201, D202, D203, D204, D205 | GeneralPurposeAlarmDevicePCB:LED_5mm_Radial | 160-1772-ND
RED 0603 | D501 | LED_SMD:LED_0603_1608Metric | C2286
Polyfuse_Small | F101, F401 | Fuse:Fuse_0603_1608Metric | C207017
MountingHole_Pad_3.5mm | H101, H102, H103, H104, H105 | GeneralPurposeAlarmDevicePCB:MountingHole_3.5mm_Pad_Via | NA
Barrel_Jack_Switch_SMT | J101 | GeneralPurposeAlarmDevicePCB:BarrelJack_CLIFF_FC681465S_SMT_Horizontal | C319134
0.100_2Pin | J102, J103 | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical | C168673
S04B-XASK-1(LF)(SN) | J105 | GeneralPurposeAlarmDevicePCB:S04B-XASK-1(LF)(SN) | C265097
RJ12_6P6C_HORZ | J401 | GeneralPurposeAlarmDevicePCB:RJ12_Amphenol_54601 | C305981
USB_B_Micro_Local | J501 | GeneralPurposeAlarmDevicePCB:USB_Micro-B_Amphenol_10118194_Horizontal | C132563
22-23-2021 | J601 | Connector_Molex:Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical | 900-0022232021-ND
MMBT2222A-7-F | Q201, Q202, Q203, Q204, Q205, Q601 | Package_TO_SOT_SMD:SOT-23 | C94515
BSS138 | Q301 | Package_TO_SOT_SMD:SOT-23 | C400505
MMBT2907ALT1G | Q602 | digikey-footprints:SOT-23-3 | C40752
1R0 | R101, R305, R307, R309, R310 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | C269434
10K | R102, R505, R603 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | C269701
330R | R103, R110, R111, R202, R204, R206, R208, R210, R501, R502, R503 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | C269711
39R | R104, R105 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | C325713
DNI | R106, R107, R306, R308 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | DNI
1K | R108, R109, R304, R602 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | C269704
4K7 | R201, R203, R205, R207, R209, R301, R302, R303, R311, R504 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | C269713
330 | R401, R402, R403, R404, R605 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | C269711
1R | R601, R604 | Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder | C269434
POT 0.375 10K | RV301 | GeneralPurposeAlarmDevicePCB:Potentiometer_Bourns_3386P_Vertical | C116281
SWITCH_TACTILE_SPST-NO_0.05A_24V | S101 | GeneralPurposeAlarmDevicePCB:Switch_Tactile_THT_6x6mm | C13828
SWITCH_TACTILE_12mmx12mm_SPST-NO_0.05A_24V | S601 | GeneralPurposeAlarmDevicePCB:SW_PUSH-12mm_WithCap_Green | C84931
LM7805_TO220 | U101 | Package_TO_SOT_THT:TO-220-3_Horizontal_TabDown | C2977083
PI_ATMEGA328P-AU-InOrder | U102 | Package_QFP:TQFP-32_7x7mm_P0.8mm | C14877
PCF8574AT | U301 | Package_SO:SOIC-16W_5.3x10.2mm_P1.27mm | C83193
LCD_20x4_Character-GPAD_SCH_LIB | U302 | GeneralPurposeAlarmDevicePCB:LCD_2004A | https://www.aliexpress.com/item/3256803213374992.html
CH340E | U501 | Package_SO:MSOP-10_3x3mm_P0.5mm | C99652
16MHZ 20PF HC-49S/SMD | XTAL101 | Crystal:Crystal_SMD_HC49-SD | TAXM16M2GLFBET2T

## KiCad design Hardware/KiCadLibrary/KiCadLibrary/KiCadLibrary.kicad_pcb

File Hardware/README.md:

# Hardware Folders
Folders for the hardware designed as GPAD (or related such as the PolyVent_SPI_Controler)

**Outline**
1. Documentation 
2. Enclosure
3. GeneralPurposeAlarmDevicePCB
4. Manufacturing
5. PolyVent_SPI_Controller

## Documentation

[Manufacturing Documentation for Version 2 PCB](./Documentation/ManufacturingUnitTestTroubleshootingRev2.md)
Details how to assemble the Printed Wiring Assemblies as received from JLCPCB version 2 PCBs of March 2023. Includes testing and troubleshooting notes.

## Enclosure
The Version 1 enclosure is mostly designed in OPEN SCAD  
Files to fabricate an enclosure are detailed in this document: [LINK](./Enclosure/README.md)

## GeneralPurposeAlarmDevicePCB
Kicanvas live view of current schematic and PCB is found at: [./GeneralPurposeAlarmDevicePCB](./GeneralPurposeAlarmDevicePCB)  

PDF, and therefore stale, schematic for Rev 2 PCB Assemblies is: [Schematic-GeneralPurposeAlarmDevicePCB-V2.2.pdf](/Hardware/GeneralPurposeAlarmDevicePCB/PDF/Schematic-GeneralPurposeAlarmDevicePCB-V2.2.pdf)

## Manufacturing
Includes the spread sheets for Bill of Materials (BOMs) to fabricate the GeneralPurposeAlarmDevicePCB.  
See the [Manufacturing README.md](./Manufacturing) for more information on the files there.

## PolyVent_SPI_Controller
Includes KiCad schematic and PCB files for an adapter PCB to fit into PolyVent Main Controller card cage and provide an SPI (and I2C) interface to other devices. The SPI interface is for the GPAD.
KiCad Schematic, PCB and bom documentation for ordering PCBs and PWAs in found in this folder.

Parts:
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
U101, U102: LCD_20x4_Character-GPAD_SCH_LIB; LCD_2004A

Connections:
+3V3: P1.4
+5V: P1.5
/0(Rx): P4.8
/1(Tx): P4.7
/2: P4.6
/3(**): P4.5
/4: P4.4
/5(**): P4.3
/6(**): P4.2
/7: P4.1
/8: P3.10
/9(**): P3.9
/10(**/SS): P3.8
/11(**/MOSI): P3.7
/12(MISO): P3.6
/13(SCK): P3.5
/A0: P2.1
/A1: P2.2
/A2: P2.3
/A3: P2.4
/A4(SDA): P2.5, P3.2
/A5(SCL): P2.6, P3.1
/AREF: P3.3
/IOREF: P1.2
/Reset: P1.3
/Vin: P1.8
GND: P1.6, P1.7, P3.4

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.

Board: 2 copper layers, 10 parts (0 on the bottom side), 3 nets, no tracks yet.

Notices in the files:
README.md:
[Firmware: Affero GPL 3.0](https://www.gnu.org/licenses/agpl-3.0.en.html#license-text)
[CERN Open Hardware Licence Version 2 - Strongly Reciprocal](https://ohwr.org/cern_ohl_s_v2.txt)
released under fully open hardware and software licenses.
Hardware/GeneralPurposeAlarmDevicePCB/GeneralPurposeAlarmDevicePCB.kicad_pcb:
GNU Affero General Public License v3.0
