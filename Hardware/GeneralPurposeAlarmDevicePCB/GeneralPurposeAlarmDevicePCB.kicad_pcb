# Repository PubInv/general-purpose-alarm-device (continued)

## KiCad design Hardware/PolyVent_SPI_Controller/PolyVent_SPI_Controller.kicad_pcb

File Hardware/PolyVent_SPI_Controller/README.md:

# NOTES FOR THIS BRANCH ONLY

This is a branch with code changes useful for testing the with the PolyVent.

1. We discovered there is a BUILTIN LED load on the CLK line. This is a problem specific to the Arduino UNO
architecture which we (mostly) copied. It can be solved in rework be desoldering restor R103 on the GPAD (NOT the PolyVent SPI card.
2. The code TEST_POLYVENT_LINES is a very SIMPLE test script for transmitting a SINGLE BYTE. It can be loaded on to the PolyVent Architecture to remove all dependence on the (somewhat complicated) VentOS code and test the transmission of SPI through the PolyVent, back plane, PolyVent SPI card, and cable to the GPAD. It has a #define at line 41 for "USE_POLYVENT_ARCH". This code should be commented out if you are using the GPAD as the cotroller, and uncommented if you are using a PolyVent/ESP32 as a controller. 
3. I may have made other changes to the GPAD controller to send SPI bytes. This is messy and needs to be cleaned up and made selectable with a compile time switch or some other mechanism.
4. The GPAD_API code itself (the main code which drives the GPAD device) has been commented out so that it ONLY tests the SPI transmission.

# PolyVent SPI Controller Card
This project is a printed circuit assembly which fits in to the card rack of the Polyvent  
This assembly brings out an SPI (Serial Peripheral Interface) on an RJ12 connector compatible with the GPAD.  
This assembly brings also out an I2C (Inter Integrated Circuit interface) on a 4 pin JST connector similar to the GPAD.  

This is collaboration of Public Invention with the [Sustainable Progress and Equality Collective (SPEC)](https://www.specollective.org/#:~:text=The%20Sustainable%20Progress%20and%20Equality,be%20catalysts%20for%20positive%20change.)

## Schematic and PCB

<a href="SCH_PolyVent_SPI_Controller.pdf" >
Link to SCH

</a>

<a href="PCB_PolyVent_SPI_Controller.pdf" >Link to PCB 

</a>

<a href="PolyVent_SPI_Controller_PCBImage.png" >Link to 3D render screen capture  
 </a>  

<a href="PolyVent_SPI_Controller.step" >Link to 3D step file.</a>

## Face Plate
The faceplate provides mechanical retention of the printed circuit assembly into the card cage and protection against ingress of dust and contaminations. 

Render of the stl.  

<a href="FacePlate_FCNative_v1_SPI_Controller.pdf" >  

Link to Face Plate mechanical drawing PDF  
</a>  

## Theory of Operation
This PCB provides two interface methods for level shifting from the 3.3V ESP32 on the PolyVent to the 5V ATmega328 on the GPAD.
They are options achieved by populating different components in the schematic. As of 20221027 17:00 the schematic does not detail these stuffing options.

* One method of using FETs as described for example here: https://www.eeweb.com/level-shifting-techniques-in-i2c-bus-design/.  This may need some design work for selecting the pull up resistors as there are no pull ups on the GPAD interface.
* The second method is to simply connect the signals from the ESP32 output pins (SCL, COPI, nCS) directly to the ATmega328 inputs and rely on the 3.3 Volt logic high to be sufficient for the Atmega328 CMOS inputs. Full analyses is: The Atmega328 logic low input is specified at 0.3*Vcc and logic input hight is specified at 0.7*Vcc. So we have 1.5 and 3.5 per the specifications. 
  
So strictly by the specification the ESP output of even the full 3.3V does not guarentee logic high on the input of the ATmega328.  
The output from the ATmega328 is resistively divided through 1K into 2K to produce 5 * 2/3 = 3.3 Volts on the CIPO signal.

There are dip siwtches for choice of any of the nCS lines of the PolyVent brought out to become the nCS signal. **CAUTION:** Onle one switch should be in the closed position.

## Testing of Version 1 PWAs  
**Reference to Schematic here:**

 <a href = "SCH_PolyVent_SPI_Controller.pdf" >  Press to load PDF. </a>
 
**Reference the PCB layers here:**  

<a href = "PCB_PolyVent_SPI_Controller.pdf" >  Press to load PDF. </a>

1. Unboxing and Mechanical
First label each with a serial number.
The first test is mechanical fit. Even before solding any connector on, slide a board in to the card cage and look for problems. Make a photograph(s) please.
Then IIRC you have three connectors to solder on and test the fit again. Photo(s) again please.

2. Electrical test.
Prepare by identifying all of the currently used chip select lines in the PolyVent firmware or be refernce to the project documentation.
Identify an unused chip select line. Set the dip switches so that one and only one switch selecting chip select is closed. Confirm on and only one Chip Select is selected with a multi meter.

3. Light and play test.
Load some kind of file into the ESP which will use this chip select for an SPI interface.  Send out the SPI interface something that the GPAD is known to react to.

4. If you have the bandwidth to do so, put an oscilliscope on the SPI interface at the test points labled nCS, COPI, CIPO, SCK. Measure for signal high voltage, signal low voltage and time rise and time fall on each signal.  Trigger the oscilliscope on the falling edge of nCS. 

Report results here

## Volunteer Skills and Skills Needed
Project Lead, Product Definition, Robert L. Read, founder of Public Invention.  
Enclosure design, component procurement for rev1, project facilitator, initial board bring-up, board layout design contributor, Lawrence Kincheloe of Speccollective who is a computer scientist by training, and an electrical engineer as well as a hobby inventor by vocation. 
Mentor and coach hardware, firmware, (Forrest) Lee Erickson Physicist who pretends to be electrical engineer and firmware developer and provider of Novel and Diverse Spelling.
Volunteers needed and welcome for review of project documentation and project design.

# License

* Firmware: GLP 3
* Hardware CERN Open Hardware License Version 2 - Strongly Reciprocal

Parts:
C101, C102, C103, C104: 39PF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN CC0603JRNPO9BN390
C105, C106, C107: 100NF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN CC0603KRX7R9BB104
D101, D102, D103: RED 0603; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN LTST-C171KRKT; Digi-Key_PN 160-1427-1-ND
F101, F102, F103: Polyfuse_Small; Fuse_0603_1608Metric; MPN 0603L100SLYR
J1: Plug 48 Way; HARTING_09231486921; MPN 09231486921
J102: RJ12_6P6C_HORZ; RJ12_Amphenol_54601; MPN 5555165-1
J103: 0.100_2Pin; PinHeader_1x02_P2.54mm_Vertical; MPN 68000-102HLF
MF101: PCB_PolyVent_SPI_Controller_VER1; NA; MPN PCB_PolyVent_SPI_Controller_VER1
Q101, Q102, Q103, Q104: BSS138; SOT-23; MPN BSS138
R101, R102: DNI; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R103, R104, R105, R107, R111, R114: DNI; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RMC06031K1%N
R106, R109, R110, R113, R117, R118, R119: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RMC06031K1%N
R108, R112, R115, R116: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RMC 0603 10K F N
R120: 1R0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RMC060315%N
SW101, SW102: SW_DIP_x08; SMDIP-16_L11.39_W6.7mm; MPN DHN-08-V-T/R
TP101: ControllerVCC; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP102: CPIO; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP103: SCK; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP104: COPI; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP105: nCS; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP106: +3.3V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP107: +5V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP108: TP_GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP109: +12V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U101: DC_DC_small; DC_DC_LM2596_small1700x830; MPN LM2596 DC-DC Buck Converter Step Down M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

Connections:
+3.3V: C105.1, F101.2, Q101.1 (G), Q102.1 (G), Q103.1 (G), Q104.1 (G), R112.1, R113.1, R115.1, R116.1, R119.2, TP106.1; also elsewhere on the board
+5V: C106.1, F102.2, R101.2, R106.1, R108.1, R109.1, R110.1, R118.2, TP107.1; also elsewhere on the board
+12V: C107.1, F103.2, J103.2, R102.2, R117.2, TP109.1, U101.1 (+IN); also elsewhere on the board
/3.3V: F101.1, J1.7, J1.23
/5V: F102.1, J1.38, J1.39
/24V/12V: F103.1, J1.5, J1.6, J1.20, J1.21, J1.22, J1.36, J1.37
/CIPO: C101.1, J102.6, Q102.3 (D), R103.1, R108.2, TP102.1
/COPI: C103.1, J102.2, Q104.3 (D), R105.1, R110.2, TP104.1
/CS_1: J1.8, SW101.15
/CS_2: J1.9, SW101.14
/CS_3: J1.10, SW101.13
/CS_4: J1.11, SW101.12
/CS_5: J1.12, SW101.11
/CS_6: J1.13, SW101.10
/CS_7: J1.14, SW101.9
/CS_8: J1.24, SW101.16
/CS_9: J1.25, SW102.16
/CS_10: J1.26, SW102.15
/CS_11: J1.27, SW102.14
/CS_12: J1.28, SW102.13
/CS_13: J1.29, SW102.12
/CS_14: J1.30, SW102.11
/CS_15: J1.45, SW102.10
/C_SCK: C102.1, J102.4, Q103.3 (D), R104.1, R109.2, TP103.1
/ControllerVcc: J102.5, J103.1, R101.1, R102.1, R120.1, TP101.1
/MISO: J1.41, Q102.2 (S), R103.2, R111.2, R113.2
/MOSI: J1.42, Q104.2 (S), R105.2, R116.2
/RESET: J1.48
/SCK: J1.40, Q103.2 (S), R104.2, R115.2
/SCL: J1.44; also elsewhere on the board
/SDA: J1.43; also elsewhere on the board
/USB1_D+: J1.16
/USB1_D-: J1.15
/USB2_D+: J1.32
/USB2_D-: J1.31
/USB3_D+: J1.47
/USB3_D-: J1.46
/nCS: C104.1, J102.1, Q101.3 (D), R106.2, R107.1, TP105.1
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, D101.1 (K), D102.1 (K), D103.1 (K), J1.1, J1.2, J1.3, J1.4, J1.17, J1.18, J1.19, J1.33, J1.34, J1.35, J102.3, R114.1, TP108.1, U101.2 (-IN), U101.4 (-OUT); also elsewhere on the board
unnamed: D101.2 (A), R117.1
unnamed: D102.2 (A), R118.1
unnamed: D103.2 (A), R119.1
unnamed: Q101.2 (S), R107.2, R112.2, SW101.1, SW101.2, SW101.3, SW101.4, SW101.5, SW101.6, SW101.7, SW101.8, SW102.1, SW102.2, SW102.3, SW102.4, SW102.5, SW102.6, SW102.7, SW102.8
unnamed: R111.1, R114.2
unnamed: R120.2, U101.3 (+OUT)

Notes on the sheet:
SPI Connector Signal Names
J1 connector (Plug) to back plane bus. Signals are 3.3 Volt logic level.
Board name: PolyVent_SPI_Controller
Adjust U101 for about 9 to 12V at ControllerVcc
SPI and I2C Interface Card for the PolyVent
CIPO: Controller In, Peripherial Out C_SCK: Controller Serial Clock (output) COPI: Controler Out, Peripherial In nCS: not Chip Select, ie /CHIP_SELECT
Power to SPI interface, 5V or 12V.
J102 is an RJ12 Connector for SPI with 5V logic level.
An interface card for the PolyVent to bring out SPI bus for the GPAD. Level shift from 5V to 3V on the CIPO. Also to bring out I2C buss through bidirectional level shifters.

Parts:
C201, C202: 39PF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN CC0603JRNPO9BN390
J201: S04B-XASK-1(LF)(SN); MPN S04B-XASK-1(LF)(SN); Digi-Key_PN 455-4090-ND
J202: 0.100_2Pin; PinHeader_1x02_P2.54mm_Vertical; MPN 68000-102HLF
Q201, Q202: BSS138; SOT-23; MPN BSS138
R201, R202, R203, R204: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RMC 0603 10K F N
R205, R206: 39R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RMC0603391%N
R207, R208: DNI; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP201: SCL_5V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP202: I2C_VCC; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP203: SDA_5V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded

Connections:
+3.3V: Q201.1 (G), Q202.1 (G), R201.1, R202.1; also elsewhere on the board
+5V: R203.1, R204.1, R207.2; also elsewhere on the board
+12V: J202.2, R208.2; also elsewhere on the board
/I2C_Level_Shifter/I2C_VCC: J201.1, J202.1, R207.1, R208.1, TP202.1
/I2C_Level_Shifter/SCL_5V: C201.1, J201.2, R205.1, TP201.1
/I2C_Level_Shifter/SDA_5V: C202.1, J201.4, R206.1, TP203.1
/SCL: Q201.2 (S), R201.2; also elsewhere on the board
/SDA: Q202.2 (S), R202.2; also elsewhere on the board
GND: C201.2, C202.2, J201.3; also elsewhere on the board
unnamed: Q201.3 (D), R203.2, R205.2
unnamed: Q202.3 (D), R204.2, R206.2

Notes on the sheet:
I2C Connector Signal Names
Power to I2C interface, 5V or 12V.
SCL_5V: Serial Clock at 5V SDA_5V: Serial Data at 5V

Board: 2 copper layers, 99.9 x 79.9 mm, 77 parts (0 on the bottom side), 43 nets.

Other parts of the board:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
Graphic1: OSHW-Logo2_7.3x6mm_SilkScreen
T1, T2, T3: JLC_ToolingHole_0576mm

## Code that names these connections

File Firmware/GPAD_API/robot_api.h:

/* robot_api.h
  header for the "robot" (low-level hardware) api

  Copyright (C) 2022 Robert Read

  This program includes free software: you can redistribute it and/or modify
  it under the terms of the GNU Affero General Public License as
  published by the Free Software Foundation, either version 3 of the
  License, or (at your option) any later version.

  See the GNU Affero General Public License for more details.
  You should have received a copy of the GNU Affero General Public License
  along with this program.  If not, see <https://www.gnu.org/licenses/>.

  This program is distributed in the hope that it will be useful,
  but WITHOUT ANY WARRANTY; without even the implied warranty of
  MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.

*/

#ifndef ROBOT_API
#define ROBOT_API 1
#include <stream.h>

//Pin definitions.  Assign symbolic constant to Arduino pin numbers.
//For more information see: https://www.arduino.cc/en/Tutorial/Foundations/DigitalPins
#define SWITCH_MUTE 2
#define TONE_PIN 8
#define LIGHT0 3
#define LIGHT1 5
#define LIGHT2 6
#define LIGHT3 9
#define LIGHT4 7

void unchanged_anunicateAlarmLevel(Stream *serialport);
void annunciateAlarmLevel(Stream *serialport);
void clearLCD(void);
void splashLCD(void);

// This module has to be initialized and called each time through the superloop
void robot_api_setup(Stream *serialport);
void robot_api_loop();
#endif

File Firmware/SPI_Controller_And_Peripheral/SPI_PERIPHERAL/SPI_PERIPHERAL.ino:

/* SPI_PERIPHERAL

Copyright (C) 2022 Robert Read
This program includes free software: you can redistribute it and/or modif
it under the terms of the GNU Affero General Public License as
published by the Free Software Foundation, either version 3 of the
License, or (at your option) any later version.
See the GNU Affero General Public License for more details.
You should have received a copy of the GNU Affero General Public License
along with this program. If not, see https://www.gnu.org/licenses/.
This program is distributed in the hope that it will be useful,
but WITHOUT ANY WARRANTY; without even the implied warranty of
MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.
*/

//SPI PERIPHERAL (ARDUINO UNO)
//SPI COMMUNICATION BETWEEN TWO ARDUINO UNOs
//CIRCUIT DIGEST

/* Hardware Notes Peripheral
   SPI Line Pin in Arduino, IO setup
  MOSI 11 or ICSP-4  Input
  MISO 12 or ICSP-1 Output
  SCK 13 or ICSP-3  Input
  SS 10 Input
*/

#define GPAD_VERSION1

#ifdef GPAD_VERSION1 //The Version 1 PCB.
//#define SS 7                                // nCS aka /SS Input on GPAD Version 1 PCB.
#define LED_PIN PD3                         // for GPAD LIGHT0
#define BUTTON_PIN PD2                      //GPAD Button to GND,  10K Resistor to +5V.

#else //The proof of concept wiring.
#define LED_PIN 7
#define BUTTON_PIN 2                          //Button to GND, 10K Resistor to +5V.

#endif

#include<SPI.h>

volatile boolean isReceived_SPI;
volatile byte peripheralReceived ;

void setup()
{
  Serial.begin(115200);
  delay(500);
  Serial.println("Starting SPI Peripheral.");
  Serial.print("Pin for SS: ");
  Serial.println(SS);

  pinMode(BUTTON_PIN, INPUT);              // Setting pin 2 as INPUT
  pinMode(LED_PIN, OUTPUT);                // Setting pin 7 as OUTPUT

  //  SPI.begin();    // IMPORTANT. Do not set SPI.begin for a peripherial device.
  pinMode(SS, INPUT_PULLUP); //Sets SS as input for peripherial
  pinMode(MOSI, OUTPUT);    //This works for Peripheral
  pinMode(MISO, OUTPUT);    //try this.
  pinMode(SCK, INPUT);                  //Sets clock as input
  SPCR |= _BV(SPE);                       //Turn on SPI in Peripheral Mode
  isReceived_SPI = false;
  SPI.attachInterrupt();                  //Interuupt ON is set for SPI commnucation
}//end setup()

//ISRs
ISR (SPI_STC_vect)                        //Inerrrput routine function
{
  peripheralReceived = SPDR;         // Value received from controller if store in variable peripheralReceived
  isReceived_SPI = true;                        //Sets isReceived_SPI as True
}//end ISR

//Functions
void updateFromSPI() {
  volatile byte peripheralSend;

  if (isReceived_SPI)                           //Logic to SET LED ON OR OFF depending upon the value recerived from controller
  { // Act on the received data.
    if (peripheralReceived == 1)
    {
      digitalWrite(LED_PIN, HIGH);        //Sets pin 7 as HIGH LED ON
      //          Serial.println("Peripheral LED ON");
    } else
    {
      digitalWrite(LED_PIN, LOW);         //Sets pin 7 as LOW LED OFF
      //          Serial.println("Peripheral LED OFF");
    }

    // Send return SPI data. Lets use a button for this example.
    peripheralSend = digitalRead(BUTTON_PIN);
    SPDR = peripheralSend;    //SPDR register of data to be shiffted out.

    Serial.print("SPI_PERIPHERAL, isReceived_SPI: ");
    Serial.println(peripheralReceived);
  }// end received
}//end function updateFromSPI

void loop()
{
  updateFromSPI();

//Check mute button for press.
    if (digitalRead(BUTTON_PIN) != HIGH) {
  //  tone(TONE_PIN, BUZZER_TEST_FREQ);
    Serial.println("Button pressed.");
//    for (int i = 0; i < 5; i++) {
//      digitalWrite(LIGHT[i], HIGH);
//    }
  } else {
//    noTone(TONE_PIN);
//    for (int i = 0; i < 5; i++) {
//      digitalWrite(LIGHT[i], LOW);
//    }
  }
  
}//end loop()

## Commit log (part)

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2022-10-28 Initial commit of pseudoSerialVent.
2022-10-28 Auto Format with CTRL T all files.
2022-10-28 Add an endurance test for GPAD API
2022-10-29 Update to flush out most of the user interface and functionality. Mute and unmute may be inverted.;
2022-10-31 Create README.md
    Written to start fulfilling issue Write a README.md for the GPAD_API #110
2022-11-02 Update README.md
    Update to reflect the new Regression Test Document. Add formatting to emphasize file or folder names.
2022-11-02 Update GPAD_API_Regression_Test_Plan.md
    Further detail past test results and add test with to be created file GPAD_API_TEST_ALPHANUM1.txt
2022-11-02 New file for testing all of alpha numeric
2022-11-02 Update GPAD_API_Regression_Test_Plan.md
    Fix actual results for all alpha numeric test.
2022-11-04 Created function to check inString for match. Checking for onPress at this time only.
2022-11-04 Update README.md
    Lee updated the API description after further work with the firmware on 20221104.
2022-11-09 GRAD_API README.md minor corrections
2022-11-09 Rename files with descriptive line endings for gitattributes management.
2022-11-09 general-alarm-device README.md minor corrections
2022-11-09 GRAD_API_TEST README.md minor corrections
2022-11-09 simulation README.md minor correction
2022-11-10 optimised I2C scan error handling
2022-11-11 improving documentation about APIs
2022-11-12 added auto-toggle function to testing on the command of long switch press
2022-11-13 Update Diagram
2022-11-13 Fixing paths to library. The previous commit may have had a path to Lees local clone.
2022-11-13 Update schematic for rework of Version 1 PCB for D7 and D10 and Reset to nRTS.
2022-11-13 Update README.md
    Fix URL to schematic PDF file.
2022-11-13 Put BUILTIN LED and resistor back on D13. Add new LED and resistor for Wink on A3.
2022-11-13 initial breakup of GPAD into several files to organize them better
2022-11-14 clean some things up
2022-11-14 adding serial files and improving specific README.
2022-11-15 Update to KiCad files for PolyVent BOM update.
2022-11-15 Update README.md
    Add links to the PolyVent files.
2022-11-17 Update README.md
    Add notes to help visitors find and understand the V1.2 schematic.
2022-11-20 refactored testing for LCD
2022-11-20 revised testGroupFunctions()
2022-11-23 simple pythob serial port script
2022-11-24 Add library parts and data sheet.
2022-11-24 Update PCB for fewer appatures on ground.
2022-11-24 Add Schematic PDF reflecting updates such as buck regulator for ControllerVCC.
2022-11-25 Change Buck Regulator for 1700x830 footprint. Update PDFs.
2022-11-25 Increase size on power traces and vias. Move and edit model number text.
2022-11-25 Add a screen capture of rendered PCB.
2022-11-25 Update README.md
    Add screen shot from ATmega specification for logic input levels.
2022-11-26 Gerbers and drill file as of 20221126.
2022-11-26 Update README.md
    Fix formatting of file heading.
2022-11-29 Experiments with Pick And Place generation.
2022-11-29 Update ManufacturingUnitTestTroubleshooting.md
    Formatting change ad descriptive change of the Reworks.
2022-11-29 Add the JLCPCB files before actual order.
2022-11-29 Tweek placement after viewing on JLCPCB.
2022-11-30 Initial troubleshooting Notes on SN5 verification problem.
2022-12-03 updated enclosure stl files and openscad source to improve button fit
2022-12-08 Update README.md
    Add file descriptions for these files used in the manufacturer of GPAD V1 PCBA in summer of 2022.
2022-12-08 Updateing for Version 2, 1K on BuiltinLED
2022-12-08 Add text to the UNO footprint front and back silk screen.
2022-12-09 MoveR104R105NearJ105
2022-12-20 test code, intermediate state
2022-12-20 Update ManufacturingUnitTestTroubleshooting.md
    Update with details on Rework 3 Remove and Relocate R103 and D102.
2022-12-24 Term proposal (line 15)
2022-12-24 Minor fix (line 20)
2022-12-27 Update README.md
    minor wording change to Phase 2 and Phase 3
2023-01-11 Add the toneSweep with README.md and images.
2023-01-24 Update ManufacturingUnitTestTroubleshooting.md
    Update correct images for WINK_LED rework. The old images put the LED on the wrong net (SCL) causing the SPI bus to mal function.
2023-01-25 Adding brief description of API implemented by SPI
2023-01-30 Update README.md
    example simple edit
2023-02-07 Update README.md
    Add additional descriptions of the files and folders in this Firmware folder
2023-02-07 Create LCD_TroubleShooting.md
    Create troubleshooting document for LCD failures.
2023-02-09 Update the to GNU Affero copyright notice to toneSweep.
2023-02-11 I2C scan timeout handling improved
2023-02-13 Removed example comment
2023-02-17 Simulate inductive boost to Piezo for greater amplitude
2023-02-21 Change UNO placement, change silkscreen. Update Gerbers and drills and STEP models.
2023-02-27 Working buzzerControl
2023-02-28 Add Adafruit buzzer to PCB. DRC no errors. Trivial warnings.
2023-03-01 Update U301 for JLCPCB in stock, Break and then fix SCH library because of illigal character in sch symbol name.
2023-03-01 Add a spread sheet for making JLCPCB bom and placement files.
2023-03-02 Updated LED diameter to 5mm, added in standoff STL files for the LED's
2023-03-02 Update README.md
    Update readme making a list out of the enclosure files.
2023-03-02 Add LED Standoffs to Schematic. Bump version to 2.1
2023-03-02 Create TestSDCard
2023-03-02 Test SD card file
    Contains code to test if the SD card works separately
2023-03-02 Add files for LED standoff in FreeCad format. Not yet right but a start. Add the Backpanel with hanging featur into the GPAD enclosure FreeCAD drawing.
2023-03-03 Update README.md
    Change the list for the Single version of STL file for the LED standoff.
2023-03-03 Update README.md
    Change file name for: U_Box_V104_GPAD_LED_Standoff_single.stl
2023-03-05 Create Pictures_Schematics
    All Schematics and Pictures of real-life circuits will be shown here for the purpose of displaying progress
2023-03-05 Demo Circuit
    Successful Audio outputting circuit using the ESP-32 38-pin version.
2023-03-08 updating the openscad file to improve printablility of parts
2023-03-08 Update README.md
    Describe the STL files to use to build future enclosures
    These are files after some changes made to V104 to make V105 at advise of JLCPCB. The file BackPanel_Hanging-Compound.stl was made in FreeCAD by "compounding" two features in FreeCAD and exporting th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
2023-03-09 Found and fixed gap on BackPanel_Hanging_Compound. Made version 2.
2023-03-10 Migrated to ESP32. Significant code commented out.
2023-03-19 updated PCB
2023-03-28 Update more audio files
2023-04-06 added LedSingle function for exporting just one LED spacer
2023-04-11 Add new document for Manufacturing and unit testing of Rev2 Printed circuit assemblies.
2023-04-21 Add Battery Control Circuitry
    Added Battery Control Circuitry schematic as well as a MOSFET to turn on and off the LCD
2023-04-25 Add files for manufacturing test. Add Rev 2.2 schematic.
2023-04-25 Update README.md
    Fix URL to schematic Rev 2.
2023-04-27 Updated all needed files for hardware
2023-05-03 Documentation For Capstone
2023-05-03 Updated audio files
2023-05-04 Update README.md
    Add the rest of the schematic pages.
2023-05-10 Update README.md
    Fix file name error. Change from: U_Box_V105_General_Alarm_Device_button.stl
    To:
    U_Box_V104_General_Alarm_Device_button.stl
2023-05-14 Update ManufacturingUnitTestTroubleshootingRev2.md
    Add a note about how boot loader programing can go wrong.
2023-05-17 Update ManufacturingUnitTestTroubleshootingRev2.md
    Link to issue with Additional Measurements of current with in subcircuits
2023-06-18 Create README.md
    Add README.md with image of faceplate mounted to a card.
2023-06-19 Improving licenses
2023-06-19 Tweaking license name
2023-06-20 Update ManufacturingUnitTestTroubleshootingRev2.md
    added in notes on using paint pens as a Tip
2023-06-20 Delete U_Box_V104_General_Alarm_Device_LED_Standoff.stl
    old rev of stand-off and JLCPCB did not want to fabricate this layout of file
    Suggestion for new ensamble print to use a spur to combine multiple small pieces together
2023-06-20 Delete alarmtest.cpp
    Duplication of function with factory test code
2023-06-20 delting old file
2023-06-20 Update README.md
    Added in instructions on exporting from source files, STL files
2023-06-21 some updates
2023-06-21 Add TechDrawing of FacePlate_FCNarive.
2023-06-22 Close page view.
2023-06-23 adding .svg
2023-06-24 Update README.md
    Remove novel spelling of peripheral.
2023-06-25 Add Text to faceplate of stl file.
2023-06-29 some improvements in the wordsmithing of abstract and description and similar products
2023-07-05 adding diagram, filling out all sections, adding references
2023-07-06 updating paper to talk about songs
2023-07-11 some improvements
2023-07-21 rearranged files after merge
2023-07-24 Update README.md
    Update for image of PCB with better 3D renders.
2023-07-25 Updated FreeCAD FacePlate file for the updated PDF.
2023-07-25 Add glossary marke down file.
2023-07-26 Update hardwareX document with BOM. Update KiCad files for LCD mounting hardware.
2023-07-27 Update ManufacturingUnitTestTroubleshootingRev2.md
    Clarify section on Missing Jumper to D10 When Load Bootloader.
2023-07-27 Add the manuracturing instructions to HardwareX document including images. Text is markdown.
2023-07-31 Minor changes
    This was imported/exported to/from google docs, a lot of formatting changes were made.
2023-08-01 Fix schematic broken by the "/" in the hex nut.
2023-08-15 Update README.md
    Rewrite to remove content made stale by the successful development of Rev 2 design. Add information referencing and about the cap stone projects.
    Giving some credit where due to the other open source resources we used.
2023-08-15 Delete HardwareX Template_20210707_for_GPAD.odt
    removing old revision
2023-08-18 review of README.md
2023-10-22 Update the HardwareX GPAD Sumission to remove the TBDs from the test results.
2023-10-22 Files for a monocrome Public Invention logo for PCBs.
2023-10-24 added reference to sources for the OpenSCAD enclosure project, per issue #245
2023-10-24 Update README.md
    Update to make more Rev 2 focused.
2023-10-24 Update README.md
    Fix some novel spelling.
2023-10-26 restored images to document
2023-10-31 Update ManufacturingUnitTestTroubleshootingRev2.md
    Remove Configuration Version 1 Assemblies. a table.
2023-11-01 Update ManufacturingUnitTestTroubleshootingRev2.md
    Update with photos of Rev 2 build.
2023-11-01 Update ManufacturingUnitTestTroubleshootingRev2.md
    Add table with current measurements of subcircuits.
2023-11-01 Update of HardwareX submission with changes to electrical tests and adding enclousre assembly.
2023-11-01 updating DOI
2024-02-18 Update README.md
    I edited the Artuino typo and also changed some of the passive voice. Let me know if you prefer passive over the active in general, and I can leave it in.
2024-05-01 improvements to use SPI Transaction, which works with both R3/Duemilanova and R4
2024-05-01 tweak
2024-05-03 adding new documentation
2024-05-06 changed image
2024-05-08 Delete doc/HardwareXRevised.doc
    obselete
2024-07-15 adding submission as of July14
2024-09-22 Create Rev2BuildCurrentOnCircuitBlocks
2025-01-19 SpeakerBaffel150x90.FCStd Add a retaining feature.
2025-01-21 Create README.md
    Showing the speaker and an idea for a Baffle on which to mount the same.
